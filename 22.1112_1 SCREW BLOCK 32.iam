# Autodesk Inventor assembly: 22.1112_1 SCREW BLOCK 32
## iProperties
Created: 2007-04
Part Number: 22.1112_1 SCREW BLOCK 32
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
